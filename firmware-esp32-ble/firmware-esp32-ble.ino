#include <Arduino.h>
#include <U8g2lib.h>
#include <Wire.h>
#include <BLEMIDI_Transport.h>
#include <hardware/BLEMIDI_ESP32.h>

// ============================================================
//  BLE MIDI SETUP
// ============================================================
BLEMIDI_CREATE_INSTANCE("PocketMaster-Ctrl", MIDI);

// ============================================================
//  HARDWARE PINS (ESP32-C3 SuperMini)
// ============================================================
#define I2C_SDA_PIN    4  // Right header
#define I2C_SCL_PIN    3  // Right header

// Live Expression Pedal
#define EXP_PIN        2  // GPIO 2 (ADC1_CH2)
#define EXP_CC         7  // Sonicake CC# 7 = Preset Volume (0-100)

// 5 SPST Footswitches
// SW1: GPIO 1, SW2: GPIO 0, SW3: GPIO 10, SW4: GPIO 20, SW5: GPIO 21
const uint8_t switchPins[5]     = {1, 0, 10, 20, 21};
bool lastSwitchState[5]         = {HIGH, HIGH, HIGH, HIGH, HIGH};
unsigned long pressStartTime[5] = {0, 0, 0, 0, 0};
bool longPressTriggered[5]      = {false, false, false, false, false};

const unsigned long LONG_PRESS_MS = 800; // Threshold for hold functions

// ============================================================
//  EXPRESSION PEDAL STATE & CALIBRATION
// ============================================================
int lastMidiVol          = -1;
float smoothedADC        = 0.0;
unsigned long lastExpScan = 0;

// Calibration deadbands: compensates for pedal gear slack
const int ADC_MIN_HEEL   = 100;   // Below this is forced to 0% volume
const int ADC_MAX_TOE    = 3950;  // Above this is forced to 100% volume

// ============================================================
//  OLED DISPLAYS (I2C)
// ============================================================
U8G2_SH1106_128X64_NONAME_F_HW_I2C screenA(U8G2_R0, U8X8_PIN_NONE); // Status / Preset (0x3C)
U8G2_SH1106_128X64_NONAME_F_HW_I2C screenB(U8G2_R0, U8X8_PIN_NONE); // Mode / Stomp States (0x3D)

// 'Skellies', 128x64px
const unsigned char epd_bitmap_Bootsplash [] PROGMEM = {
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x02, 0x02, 0x90, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x10, 0x01, 0x09, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x02, 0x02, 0x84, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xca, 0x1a, 0x01, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x19, 0xbd, 0x19, 0x09, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xeb, 0x9c, 0x4b, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5a, 0x51, 0x12, 0x10, 0x0a, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x14, 0xe5, 0x2a, 0x14, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x8b, 0x4a, 0x55, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x98, 0x25, 0x20, 0x2b, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x4b, 0x7b, 0xad, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x28, 0x95, 0x55, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x14, 0xa5, 0xb5, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x89, 0x10, 0xab, 0x0a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0x00, 0xe1, 0x1a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0b, 0x0a, 0x58, 0x09, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x69, 0x80, 0x66, 0x2b, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xdd, 0x01, 0x05, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xab, 0x02, 0xc0, 0x22, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0x5f, 0x06, 0x80, 0x52, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xfe, 0x04, 0x80, 0x2c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xfb, 0x19, 0x40, 0x75, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x90, 0x94, 0x3a, 0xc0, 0xd6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xfc, 0xb3, 0xb0, 0x86, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x70, 0xa5, 0xa0, 0x45, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0x01, 0xe6, 0x34, 0x97, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xe8, 0xe7, 0x9b, 0x5a, 0x47, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x84, 0x9a, 0x75, 0x63, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xe0, 0x1d, 0xaf, 0x4a, 0x33, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xc8, 0x3f, 0x54, 0xbe, 0x63, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x7a, 0x58, 0x55, 0xb2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xe8, 0xa1, 0x21, 0x97, 0x69, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0xbf, 0xe2, 0xbf, 0x59, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xff, 0x0f, 0x2c, 0x69, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xd1, 0x55, 0xd2, 0x35, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x2f, 0xda, 0x34, 0x5d, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xd0, 0xfe, 0xaf, 0x99, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xf5, 0x53, 0xd2, 0xb0, 0x15, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xd0, 0x0e, 0xb4, 0xe7, 0xac, 0x0a, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0xfa, 0x57, 0x0f, 0xae, 0x0a, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xf5, 0xeb, 0x60, 0x7a, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0x9e, 0x54, 0x7f, 0x4a, 0x09, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xe9, 0x57, 0x3f, 0x25, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xf2, 0x55, 0x40, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x84, 0xbe, 0x1f, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x40, 0x31, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xe0, 0x95, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x51, 0xeb, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x52, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0x46, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xa0, 0x44, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xb4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x8b, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x24, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

// ============================================================
//  OPERATIONAL MODES & STATE
// ============================================================
enum ControllerMode { MODE_PRESET, MODE_STOMP };
ControllerMode currentMode = MODE_PRESET;

int currentPreset = 1; // 1 to 50 (P01 to P50)
int currentBank   = 0; // 0 to 4 (Banks 01 to 05)

// Stomp Toggle States (false = OFF, true = ON)
bool fxDrive  = false; // CC 45
bool fxDelay  = false; // CC 50
bool fxMod    = false; // CC 49
bool fxReverb = false; // CC 51
bool fxTuner  = false; // CC 58

// ============================================================
//  UI RENDERING
// ============================================================
void updateScreens() {
  if (currentMode == MODE_PRESET) {
    // Screen B: Bank & Switch Hints
    screenB.clearBuffer();
    screenB.setFont(u8g2_font_7x13_tr);
    screenB.drawFrame(0, 0, 128, 64);
    screenB.drawStr(12, 14, "PRESET MODE");
    screenB.drawHLine(0, 18, 128);

    screenB.setFont(u8g2_font_ncenB10_tr);
    screenB.setCursor(14, 34);
    screenB.printf("B %02d (P%02d-P%02d)", currentBank + 1, (currentBank * 10) + 1, (currentBank * 10) + 10);

    screenB.setFont(u8g2_font_5x7_tr);
    screenB.drawStr(6, 48, "SW1:PREV   SW2:NEXT");
    screenB.drawStr(6, 58, "HOLD SW1:FX  SW2:BANK+");
    screenB.sendBuffer();

    // Screen A: Large Target Preset
    screenA.clearBuffer();
    screenA.setFont(u8g2_font_7x13_tr);
    screenA.drawFrame(0, 0, 128, 64);
    screenA.drawStr(16, 14, "ACTIVE PATCH");
    screenA.drawHLine(0, 18, 128);

    screenA.setFont(u8g2_font_logisoso28_tr);
    char pStr[8];
    snprintf(pStr, sizeof(pStr), "P%02d", currentPreset);
    int w = screenA.getStrWidth(pStr);
    screenA.setCursor((128 - w) / 2, 54);
    screenA.print(pStr);
    screenA.sendBuffer();

  } else { // MODE_STOMP
    // Screen B: Stomp Controls
    screenB.clearBuffer();
    screenB.setFont(u8g2_font_7x13_tr);
    screenB.drawFrame(0, 0, 128, 64);
    screenB.drawStr(12, 14, "STOMP MODE");
    screenB.drawHLine(0, 18, 128);

    screenB.setFont(u8g2_font_6x10_tr);
    screenB.setCursor(8, 32);
    screenB.printf("DRV:%s  DLY:%s", fxDrive ? "ON " : "OFF", fxDelay ? "ON " : "OFF");
    screenB.setCursor(8, 45);
    screenB.printf("MOD:%s  RVB:%s", fxMod ? "ON " : "OFF", fxReverb ? "ON " : "OFF");

    screenB.setFont(u8g2_font_5x7_tr);
    screenB.drawStr(8, 58, "HOLD SW1 -> PRESETS");
    screenB.sendBuffer();

    // Screen A: Tuner & Direct FX Status
    screenA.clearBuffer();
    screenA.setFont(u8g2_font_7x13_tr);
    screenA.drawFrame(0, 0, 128, 64);
    screenA.drawStr(24, 14, "EFFECT BLOCKS");
    screenA.drawHLine(0, 18, 128);

    if (fxTuner) {
      screenA.setFont(u8g2_font_ncenB14_tr);
      screenA.drawStr(26, 44, "* TUNER *");
    } else {
      screenA.setFont(u8g2_font_ncenB10_tr);
      screenA.setCursor(14, 38);
      screenA.printf("PATCH: P%02d", currentPreset);
      screenA.setFont(u8g2_font_5x7_tr);
      screenA.drawStr(14, 52, "SW5: TOGGLE TUNER");
    }
    screenA.sendBuffer();
  }
}

// ============================================================
//  MIDI ACTION DISPATCHERS
// ============================================================
void sendPresetJump(int preset) {
  if (preset < 1) preset = 1;
  if (preset > 50) preset = 50;
  currentPreset = preset;
  currentBank = (currentPreset - 1) / 10;
  
  // Sonicake manual page 20: CC# 1 selects preset 1-50 (P01-P50)
  MIDI.sendControlChange(1, currentPreset, 1);
  Serial.printf("Sent Preset Jump: CC#1 Value %d (P%02d)\n", currentPreset, currentPreset);
  updateScreens();
}

void toggleFX(uint8_t ccNumber, bool &state, const char* name) {
  state = !state;
  uint8_t value = state ? 127 : 0; // 0-63 OFF, 64-127 ON
  MIDI.sendControlChange(ccNumber, value, 1);
  Serial.printf("Toggled %s: CC#%d Value %d\n", name, ccNumber, value);
  updateScreens();
}

// ============================================================
//  EXPRESSION PEDAL PROCESSING
// ============================================================
void processExpressionPedal() {
  // Rate-limit ADC polling to every 15ms (~66Hz) to preserve BLE bandwidth
  if (millis() - lastExpScan < 15) return;
  lastExpScan = millis();

  int rawADC = analogRead(EXP_PIN);

  // 1. Exponential Moving Average (EMA) low-pass filter to eliminate analog jitter
  smoothedADC = (smoothedADC * 0.82) + (rawADC * 0.18);
  int filtered = (int)smoothedADC;

  // 2. Clamp into calibrated mechanical sweep range
  filtered = constrain(filtered, ADC_MIN_HEEL, ADC_MAX_TOE);

  // 3. Normalize to a 0.0 to 1.0 floating point range
  float normalized = (float)(filtered - ADC_MIN_HEEL) / (float)(ADC_MAX_TOE - ADC_MIN_HEEL);

  // 4. Logarithmic / Audio Taper Curve:
  // Quadratic curve provides a natural musical swell rather than a sudden jump
  float audioCurve = pow(normalized, 2.0);

  // 5. Scale to Pocket Master's volume scale (0 to 100)
  int targetVol = (int)(audioCurve * 100.0);

  // 6. Transmit ONLY when value changes by at least 1 unit
  if (targetVol != lastMidiVol) {
    MIDI.sendControlChange(EXP_CC, targetVol, 1); // Channel 1
    lastMidiVol = targetVol;
    Serial.printf("EXP -> Preset Vol [CC#7]: %d\n", targetVol);
  }
}

// ============================================================
//  BOOTSPLASH
// ============================================================
void showBootSplash() {
  screenA.clearBuffer();
  screenA.drawXBMP(0, 0, 128, 64, epd_bitmap_Bootsplash);
  screenA.sendBuffer();

  screenB.clearBuffer();
  screenB.drawXBMP(0, 0, 128, 64, epd_bitmap_Bootsplash);
  screenB.sendBuffer();

  delay(1500);
}

// ============================================================
//  SETUP
// ============================================================
void setup() {
  Serial.begin(115200);

  Wire.begin(I2C_SDA_PIN, I2C_SCL_PIN);
  screenA.setI2CAddress(0x3C * 2);
  screenB.setI2CAddress(0x3D * 2);
  screenA.begin();
  screenB.begin();

  showBootSplash();

  for (int i = 0; i < 5; i++) {
    pinMode(switchPins[i], INPUT_PULLUP);
  }

  // Setup expression input pin resolution (12-bit: 0-4095)
  pinMode(EXP_PIN, INPUT);
  analogReadResolution(12);

  MIDI.begin();
  sendPresetJump(1); // Boot to P01
}

// ============================================================
//  MAIN LOOP
// ============================================================
void loop() {
  unsigned long now = millis();

  // 1. Process Expression Pedal (rate-limited internally)
  processExpressionPedal();

  // 2. Scan Footswitches
  for (int i = 0; i < 5; i++) {
    int reading = digitalRead(switchPins[i]);

    // Button Pressed
    if (reading == LOW && lastSwitchState[i] == HIGH) {
      pressStartTime[i] = now;
      longPressTriggered[i] = false;
    }

    // Button Held Down (Long Press)
    if (reading == LOW && !longPressTriggered[i]) {
      if ((now - pressStartTime[i]) >= LONG_PRESS_MS) {
        longPressTriggered[i] = true;

        if (i == 0) {
          // SW1 Long Press: Toggle Mode
          currentMode = (currentMode == MODE_PRESET) ? MODE_STOMP : MODE_PRESET;
          Serial.printf("Mode switched to: %s\n", (currentMode == MODE_PRESET ? "PRESET" : "STOMP"));
          updateScreens();
        } 
        else if (i == 1 && currentMode == MODE_PRESET) {
          // SW2 Long Press: Bank Up
          currentBank = (currentBank + 1) % 5;
          sendPresetJump((currentBank * 10) + 1);
        }
      }
    }

    // Button Released (Short Tap)
    if (reading == HIGH && lastSwitchState[i] == LOW) {
      if (!longPressTriggered[i]) {
        // Handle Short Tap Actions
        if (currentMode == MODE_PRESET) {
          switch (i) {
            case 0: // SW1: Preset Down (CC# 24)
              MIDI.sendControlChange(24, 127, 1);
              if (currentPreset > 1) currentPreset--;
              else currentPreset = 50;
              currentBank = (currentPreset - 1) / 10;
              updateScreens();
              break;

            case 1: // SW2: Preset Up (CC# 25)
              MIDI.sendControlChange(25, 127, 1);
              if (currentPreset < 50) currentPreset++;
              else currentPreset = 1;
              currentBank = (currentPreset - 1) / 10;
              updateScreens();
              break;

            case 2: // SW3: Jump to Slot 1 in current bank
              sendPresetJump((currentBank * 10) + 1);
              break;

            case 3: // SW4: Jump to Slot 2 in current bank
              sendPresetJump((currentBank * 10) + 2);
              break;

            case 4: // SW5: Jump to Slot 3 in current bank
              sendPresetJump((currentBank * 10) + 3);
              break;
          }
        } 
        else { // MODE_STOMP
          switch (i) {
            case 0: // SW1: Toggle Drive (CC# 45)
              toggleFX(45, fxDrive, "DRIVE");
              break;

            case 1: // SW2: Toggle Delay (CC# 50)
              toggleFX(50, fxDelay, "DELAY");
              break;

            case 2: // SW3: Toggle Modulation / FX2 (CC# 49)
              toggleFX(49, fxMod, "MOD/FX2");
              break;

            case 3: // SW4: Toggle Reverb (CC# 51)
              toggleFX(51, fxReverb, "REVERB");
              break;

            case 4: // SW5: Toggle Tuner (CC# 58)
              toggleFX(58, fxTuner, "TUNER");
              break;
          }
        }
      }
    }

    lastSwitchState[i] = reading;
  }

  delay(2);
}